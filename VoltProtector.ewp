# IAR project VoltProtector.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: VoltProtector.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: buttons.cpp buttons.h crc.cpp crc.h delay.cpp delay.h device.h eeprom.cpp eeprom.h hardware.cpp hardware.h ind7seg.cpp ind7seg.h macros.h main.cpp program.cpp program.h relayout.cpp relayout.h voltmeter.cpp voltmeter.h
